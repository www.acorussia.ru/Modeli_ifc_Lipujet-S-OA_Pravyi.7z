Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
Time: 2017-05-22T17:25:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 22 17:25:34 2017 * Host: IN-BLR-PC-0012 * Database: C:\Users\palleri\AppData\Local\Temp\{C1E962BE-7734-4869-A1CA-D440CF5C4743}\ifc * Database version: 5507 * Database creation date: Mon May 22 17:25:33 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 22 17:25:33 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 22 17:25:33 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Identity Data - Type Name: Level 1; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowController: std, ZZZ_do not use_ME_ST_filling device for Lipurex_ACO:std:16315
In: Level 1
Type - Description: Filling device; PredefinedType: FAUCET; Material: Stainless Steel, Brushed
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC010071; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_P_c01_diameter: 20 mm
Type - Identity Data - Description: Filling device; LOD: LOD 400; Manufacturer: ACO; Model: ACO filling device for Lipurex; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Free outlet as per DIN 1988 Part 4; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO
Type - Plumbing - p_c01_flow: 0.105944 m3/s
Type - Structural - RSen_S_net_mass: 2.3
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - Moves With Nearby Elements: no; Offset: 1583 mm
Dimensions - Area: 0.0761672 m2; Volume: 0.00141803 m3
General - RSen_C_intended_use: Entwässerungssysteme
Identity Data - Mark: 12; RSen_C_code_article: 7602.00.25; RSen_C_code_gtin: 04002626143303; RSen_C_description: ACO Fülleinheit für Lipurex-O,-OD,-R,-RD
Other - option: 0; Family: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std; Family and Type: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std; Type: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std; Type Id: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std
Phasing - Phase Created: New Construction

# IfcFlowTerminal: NS10, ME_ST_lipurat oa extension stage 3_ACO:NS10:16310
In: Level 1
Type - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; PredefinedType: GREASEINTERCEPTOR; Material: PVC, White, Steel, Blue, Stainless Steel, Brushed
Type - Electrical - Loads - RSen_E_c01_load_classification: Power; RSen_E_powerfactor: 1
Type - Electrical Engineering - RSen_E_c01_3_phase: yes; RSen_E_c01_current: 16 A; RSen_E_c01_number_of_poles: 3; RSen_E_c01_subclass_motor: yes; RSen_E_c01_voltage: 400 V
Type - General - instructions_for_use: http://katalog.aco-haustechnik.de/ilcatalogue/download/ZG9jdW1lbnQvZG93bmxvYWQucGRmL2RlL0VCQV9GQV9GcmVpYXVmc3RlbGx1bmdfcnVuZF91bmRfb3ZhbF9fNDUwMDUucGRm/EBA_FA_Freiaufstellung_rund_und_oval__45005.pdf; RSen_C_code_ETIM: EC010271; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_info_technical: http://katalog.aco-haustechnik.de/Home/Produkte/Clean/Fettabscheider/Freiaufstellung/Vollentsorgung/Ovale-Bauform-Edelstahl-1.4571/Lipurat-OA-Ausbaustufe-3; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; LOD: LOD 400; Manufacturer: ACO; Model: NS 10; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Building Supervisory Authority approval Z-54.1-414; Type Name: NS10
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ME_ST_lipurat oa extension stage 3_ACO
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: NS10
Constraints - clearance_zone: no; DN_sanitary: yes; filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; OD_sanitary: no; Offset: 0 mm; right: yes; sight_glass: yes
Dimensions - Area: 20.8534 m2; D: 160 mm; DN: 150 mm; H: 1510 mm; H1: 1255 mm; H2: 1185 mm; H3: 1570 mm; H4: 1950 mm; L1: 2345 mm; L2: 2610 mm; L3: 115 mm; Volume: 0.0216055 m3; W1: 885 mm; W2: 1010 mm
Electrical - Loads - RSen_E_c01_apparent_power_phase_1: 1300 W; RSen_E_c01_apparent_power_phase_2: 1300 W; RSen_E_c01_apparent_power_phase_3: 1300 W
Electrical Engineering - RSen_E_c01_apparent_power: 3900 W; RSen_E_connected_fase: 1
General - RSen_P_c01_diameter: 150 mm; RSen_P_c02_diameter: 150 mm; RSen_P_c03_diameter: 100 mm; RSen_P_c04_diameter: 20 mm; RSen_P_c05_diameter: 65 mm
Identity Data - Mark: 9; RSen_C_code_article: 7580.74.42; RSen_C_code_gtin: 04002626301352; RSen_C_description: ACO Fettabscheid. Lipurat OA NS10 Dirabsg.+HD-Rg.ov.rechts
Mechanical - RSen_P_c04_flow: 0 m3/s; System Classification: Sanitary,Vent,Domestic Cold Water,Other,Power
Model Properties - cleaninghead_X: 1172 mm; clearance_back: 555 mm; clearance_entry: 2305 mm; clearance_exit: 1505 mm; clearance_front: 1105 mm; clearance_top: 2550 mm; drain_DN: 65 mm; drain_OD: 76 mm; drain_X: 162.3 mm; drain_Y: 420.4 mm; drain_Z: 127 mm; motor_X: 1182 mm; motor_Z: 680 mm; switchbox_position: 90 deg; switchbox_X: 271.9 mm; switchbox_Y: 542 mm; switchbox_Z: 1259.3 mm
Other - cold_water_connector: cw in; connector_escape_message: Nicht verwenden; extension_stage_lookup_table_name: lipurex_oa_extension_stage_3; Family: ME_ST_lipurat oa extension stage 3_ACO: NS10; Family and Type: ME_ST_lipurat oa extension stage 3_ACO: NS10; help_connected_phase: 3; L2_half: 1305 mm; lookup_table_name: lipurex_basic; no_option: 0; option: 1; options_lookup_table_name: lipurex_options; R: 80 mm; Type: ME_ST_lipurat oa extension stage 3_ACO: NS10; Type Id: ME_ST_lipurat oa extension stage 3_ACO: NS10; vent_DN: 100 mm; vent_OD: 110 mm; W1_half: 442.5 mm
Phasing - Phase Created: New Construction
Plumbing - grease_store_capacity: 0.52 m3; overall_capacity: 2 m3; sludge_trap_capacity: 1 m3
Structural - RSen_S_gross_mass: 2350; RSen_S_net_mass: 350

# IfcFlowTerminal: std, ZZZ_do not use_ME_ST_lipurex_o_options_ACO:std:16311
In: Level 1
Type - PredefinedType: GREASEINTERCEPTOR; Material: Plastic, White, HDPE, Red, Stainless Steel, Brushed
Type - Identity Data - Manufacturer: ACO; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_lipurex_o_options_ACO
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; Offset: 0 mm; right: yes; sight_glass: yes; Moves With Nearby Elements: no
Dimensions - acces_exit_X_pos: 2060 mm; access_entry_diameter: 504 mm; access_entry_X_position: 492 mm; Area: 7.91637 m2; b_void_X1: 528 mm; b_void_X2: 652 mm; b_void_X3: 2242 mm; b_void_Z2: 158 mm; b_void_Z3: 254 mm; corner_length: 102 mm; cover_Z_position: 1565 mm; D: 160 mm; disposalpump_flange_OD: 220 mm; disposalpump_flange length: 23.5 mm; disposalpump_OD: 114.3 mm; disposalpump_Z: 136 mm; DN: 150 mm; H: 1510 mm; H1: 1255 mm; H2: 1185 mm; H3: 1570 mm; H4: 1950 mm; inlet_length: 1307.5 mm; L1: 2345 mm; L2: 2610 mm; L3: 115 mm; logo_Z: 320 mm; outlet_length: 1307.5 mm; rib_depth: 39 mm; rib1_X: 467 mm; rib2_X: 467 mm; rib3_X: 947 mm; rib4_X: 947 mm; rib5_X: 1397 mm; rib6_X: 1397 mm; rib7_X: 1847 mm; rib8_X: 1847 mm; vent_offset: 442.5 mm; vent_X_position: 1618 mm; Volume: 2.82396 m3; W1: 885 mm; W2: 1010 mm; waterinlet_height: 304 mm; waterinlet_OD: 76.1 mm; waterinlet_offset: 182.5 mm; waterinlet_X: 97 mm; waterinlet_Z: 1279 mm
Identity Data - Mark: 10
Model Properties - glass_position: 90 deg; glass_X: 1172 mm; glass_Z: 1049.5 mm; grease_measure_end_angle: 85 deg; grease_measure_start_angle: 90 deg; grease_measure_X: 873 mm; grease_measure_Y: 500 mm; grease_measure_Z: 1510 mm; heatrod_position: 90 deg; heatrod_X: 1172 mm; heatrod_Z: 849.5 mm
Other - drain_length: 26.5 mm; drain_OD: 54 mm; drain_offset: 282.5 mm; drain_Z: 68 mm; Family: ZZZ_do not use_ME_ST_lipurex_o_options_ACO: std; Family and Type: ZZZ_do not use_ME_ST_lipurex_o_options_ACO: std; filling_device_option: 0; grease_measure_option: 1; heatrod_option: 1; L2_half: 1305 mm; logo_position: 90 deg; lookup_table_name: lipurex_basic; options_lookup_table_name: lipurex_options; R: 80 mm; rev_end: 5 deg; rev_start: 0 deg; rib1_H: 1510 mm; rib1_Z_offset: 50 mm; rib2_H: 1510 mm; rib2_Z_offset: 50 mm; rib3_H: 1510 mm; rib3_Z_offset: 50 mm; rib4_H: 1510 mm; rib4_Z_offset: 50 mm; rib5_H: 1510 mm; rib5_Z_offset: 50 mm; rib6_H: 1510 mm; rib6_Z_offset: 50 mm; rib7_H: 1510 mm; rib7_Z_offset: 50 mm; rib8_H: 1510 mm; rib8_Z_offset: 50 mm; sight_glass_option: 0; Type: ZZZ_do not use_ME_ST_lipurex_o_options_ACO: std; type_index: 10; Type Id: ZZZ_do not use_ME_ST_lipurex_o_options_ACO: std; vent_DN: 100 mm; vent_length: 50 mm; vent_OD: 110 mm; W1_half: 442.5 mm
Phasing - Phase Created: New Construction

# IfcWindow: std, ZZZ_do not use_ME_PE_viewing window Lipurex_ACO:std:16314
In: Level 1
Type - Description: Viewing window; ParameterTakesPrecedence: no; Sizeable: no; Material: HDPE, Red, HDPE, Black, HDPE, Grey
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC011162; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Viewing window; LOD: LOD 400; Manufacturer: ACO; Model: ACO viewing window; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Nominal width: DN 200; Type Name: std
Type - Materials and Finishes - RSen_C_material: HDPE, Grey
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_viewing window Lipurex_ACO
Type - Structural - RSen_S_net_mass: 2.3
OverallHeight: 75 mm; OverallWidth: 250 mm
Pset_WindowCommon - Reference: std; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: ACO
BaseQuantities - Area: 0.0878948 m2
Constraints - Moves With Nearby Elements: no; Offset: 1049.5 mm
Dimensions - Area: 0.0878948 m2; Volume: 0.00175086 m3
Identity Data - Mark: 11; RSen_C_code_article: 7602.00.26; RSen_C_code_gtin: 04002626143310; RSen_C_description: ACO Schauglas LW 200 f. Lipurex-O,-OD,-R,-RD
Other - Family: ZZZ_do not use_ME_PE_viewing window Lipurex_ACO: std; Family and Type: ZZZ_do not use_ME_PE_viewing window Lipurex_ACO: std; option: 0; Type: ZZZ_do not use_ME_PE_viewing window Lipurex_ACO: std; Type Id: ZZZ_do not use_ME_PE_viewing window Lipurex_ACO: std
Phasing - Phase Created: New Construction
